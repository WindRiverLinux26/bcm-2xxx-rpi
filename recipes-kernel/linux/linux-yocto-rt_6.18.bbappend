require linux-yocto-bcm-2xxx-rpi.inc

KBRANCH:rpi = "v6.18/standard/preempt-rt/bcm-2xxx-rpi"

LINUX_VERSION:rpi ?= "6.18.x"
